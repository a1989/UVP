# Keil uVision project Platform.uvproj, settings and files
target Platform (ARM-ADS)
  device: STM32F429ZI STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Platform +hex
  c flags: Optim=2 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx
  c include: ..\OS\uCOS_III\Cfg\Template;..\OS\uCOS_III\Ports;..\OS\uCOS_III\Source;..\OS\uC_CPU\Cfg;..\OS\uC_CPU\Ports;..\OS\uC_LIB\Cfg;..\OS\uC_LIB\Ports;..\GUI\Config;..\GUI\GUI_X;..\GUI\LIB\Include;..\GUI\LCD_Driver\lcd;..\GUI\LCD_Driver\Touch;..\APP;..\BSP\STM32F4xx_StdPeriph_Driver\inc;..\APP\3D_Printer\Function;..\APP\3D_Printer\Stepper;..\APP\3D_Printer\Temperature;..\APP\3D_Printer\Config;..\GUI\GUI\inc;..\GUI\emWinDemo;..\APP\3D_Printer\USART;..\BSP;..\APP\Win;..\FATFS
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MDK_ARM
    ../BSP/: startup_stm32f429_439xx.s
  group CMSIS
    ../BSP/: system_stm32f4xx.c
  group User
    ../APP/: main.c app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h stm32f4xx_it.c
  group BSP
    ../BSP/: bsp.c bsp.h bsp_int.c bsp_periph.c bsp_os.c
  group StdPeriph_Driver
    ../BSP/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_fmc.c stm32f4xx_exti.c stm32f4xx_spi.c stm32f4xx_syscfg.c
  group uC/CPU
    ../OS/uC_CPU/Ports/: cpu_core.c cpu_core.h cpu_def.h
    ../OS/uC_CPU/Cfg/: cpu.h cpu_a.asm cpu_c.c
  group uC/LIB
    ../OS/uC_LIB/Cfg/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../OS/uC_LIB/Ports/: lib_mem_a.asm
  group uCOS-III_Source
    ../OS/uCOS_III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group uCOS-III_Ports
    ../OS/uCOS_III/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group LCD_Driver
    ../GUI/LCD_Driver/lcd/: asc12.c asc16.c hz12.c hz16.c lcd_ra8875.c
  group GUI/Config
    ../GUI/Config/: GUIConf.c GUIDRV_Template.c LCDConf.c
  group GUI/Lib
    ../GUI/Lib/: STemWin522_CM4_OS_Keil.lib
  group GUI_X
    ../GUI/GUI_X/: GUI_X_Touch_Analog.c GUI_X_OS.c
  group Function
    ../APP/3D_Printer/Function/: function.c
  group Temperature
    ../APP/3D_Printer/Temperature/: temperature.c
  group Stepper
    ../APP/3D_Printer/Stepper/: planner.c stepper.c
  group Config
    ../APP/3D_Printer/Config/: setpins.c
  group GUIDEMO
    ../GUI/emWinDemo/: GUIDEMO.c GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
  group USART
    ../APP/3D_Printer/USART/: scarausart.c
  group Win
    ../APP/Win/: MainWindow.c ControlWindow.c MoveAxisWindow.c FilamentWindow.c PreheatSettingFramewinDLG.c PreheatWindow.c PrintingFramewinDLG.c PrintingWindowDLG.c SDWindow.c SDWindowFramewinDLG.c SDWindowListview.c
  group SD
    ../FATFS/: sd.c
  group FATFS
    ../FATFS/: diskio.c exfuns.c ff.c malloc.c cc936.c
